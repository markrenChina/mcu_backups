# Keil uVision project display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: display_main.c Nixie.c Nixie.h
