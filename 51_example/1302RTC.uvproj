# Keil uVision project 1302RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1302RTC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1302rtc_main.c lcd1602.c lcd1602.h public.c public.h DS1302.h DS1302.c
