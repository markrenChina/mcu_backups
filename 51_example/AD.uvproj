# Keil uVision project AD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: AD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AD_main.c public.c public.h XP2046.c XP2046.h lcd1602.h lcd1602.c
