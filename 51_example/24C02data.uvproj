# Keil uVision project 24C02data.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 24C02data +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 24C02_main.c lcd1602.c lcd1602.h public.c public.h button.c button.h I2C.c I2C.h AT24C02.c AT24C02.h
