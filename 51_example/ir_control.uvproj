# Keil uVision project ir_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ir_control +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ir_conttrol_main.c public.h public.c lcd1602.h lcd1602.c int0.c int0.h Timer0_count.c Timer0_count.h
