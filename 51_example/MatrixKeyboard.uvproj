# Keil uVision project MatrixKeyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: MatrixKeyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: matrix_keyboard_main.c lcd1602.c lcd1602.h public.c public.h MatrixKey.c MatrixKey.h
