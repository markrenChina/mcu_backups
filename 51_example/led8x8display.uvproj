# Keil uVision project led8x8display.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: led8x8display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led8x8display_main.c public.c public.h matrix_led.c matrix_led.h
