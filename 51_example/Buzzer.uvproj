# Keil uVision project Buzzer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: buzzer_main.c public.c public.h Timer0.c Timer0.h Nixie.c Nixie.h button.c button.h Buzzer.c Buzzer.h
