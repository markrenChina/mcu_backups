# Keil uVision project motor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: motor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: motor_main.c public.c public.h button.h button.c Timer0.c Timer0.h Nixie.c Nixie.h
